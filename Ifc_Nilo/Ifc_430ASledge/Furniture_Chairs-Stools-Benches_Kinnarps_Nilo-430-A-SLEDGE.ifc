Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Furniture_Chairs-Stools-Benches_Kinnarps_Nilo-430-A-SLEDGE.ifc
Time: 2022-03-22T16:32:22
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: Nilo 430 A SLEDGE
ePset_BIMobjectScript - LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Nilo 430 A SLEDGE; SKU (BO_prodsku): nilo-430a-sledge; ManufacturName (BO_Manufac): Kinnarps; BrandUrl (BO_brandurl): http://www.kinnarps.com/; EditionNumber (BO_edinum): 1; Width (BO_width): 0; Height (BO_height): 0; Depth (BO_depth): 0; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/kinnarps/product/nilo-430a-sledge; ProductDataUrl (BO_prodaturl): bimobject.com/kinnarps/product/nilo-430a-sledge; ProductUrl (BO_producturl): https://www.kinnarps.com/products/seating/chairs/nilo/; BimObjectMainCategory (BO_bomaincat): Furniture; BimObjectMainCategoryCode (BO_bomaincat_code): furniture; BimObjectCategory (BO_bocat): Chairs, Stools & Benches; BimObjectCategoryCode (BO_bocat_code): chairs-stools-benches; IfcClassification (BO_ifcclas): Furniture; OmniClassCode (BO_omniclass_code): 23-21 23 13 11; OmniClassDescription (BO_omniclass_name): Residential Chairs; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
